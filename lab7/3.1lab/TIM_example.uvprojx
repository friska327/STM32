# Keil uVision project TIM_example.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIM_example +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c my_lib.h interrupt.h my_lib.c interrupt.c I2C.c I2C.h ADC.c SPI.c SPI.h RTC.h RTC.c FLASH.h
    ../../lab5/3.1lab/: ds18b20.h ds18b20.c USART.c USART.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
